# Keil uVision project ep3-smno.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ep1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: try ex3 smno3.asm
